# Repository oldgerman/Smoothieboard-10x10-5driver

File README.md:

# Smoothieboard-10x10-5driver
Modified according to [Smoothieboard v1.1 5driver](https://www.reprap.org/wiki/Smoothieboard), a more compact and cost-effective design.

## 版本

- 2020-10-13 - 首次开源的版本
- 2020-10-21 - 加宽A5984 OUT引脚的线宽，调整对比见[此处](https://github.com/oldgerman/Smoothieboard-10x10-5driver/blob/master/2020-10-21/image/A5984-changed.png)，1013的钢网文件缺失已补上，但推荐打1021版本
- 2020-12-10 - 优化DCDC电感布线，元件相比2020-10-21未做移动，[布线参考](https://www.monolithicpower.com/en/support/videos/emc-optimized-buck-converter-layout.html)

## Pinout & Pin capabilities

官方抽不出人手绘制fritzing风格的pinout，我根据[Smoothieboard v1.1的pinout](http://smoothieware.org/pinout)乾坤大挪移，建议与原版对比着看

<table>
    <td><image src = 2020-10-21_版本/image/Smoothie-10x10-pinout-map-mini.png></td>
    <td><image src = 2020-10-21_版本/image/Smoothie-10x10-pin-capabilities-mini.png></td>
</table>

## 详细指南

见根目录的：冰沙主板10x10制作笔记.pdf（约30MB）

## 如果...那么不建议使用冰沙

相信各位大侠因为想做贴片机才自远方来，除非你想做基于openpnp的贴片机才建议使用冰沙（32细分最高可能是稳定贴0402阻容，0201就不好说了），但如果你想做3D打印机，相比现在TMC2208步进驱动器基本成为3D打印机的标配（1.4A/36V 256细分 参考价7￥），冰沙的A5984步进驱动器（2.0A/40V 32细分 深水价4￥，但是2A电流香啊）显得过时，因此若冰沙固件的无需编译即可配置的功能对你做机器的帮助不大，或你预算充足，对256细分以及静音有要求，那么不建议使用冰沙主板diy 3D打印机。可以选购常见的基于STM32F407的五轴主板配TMC2208（细分更高且更静音但电流较小），若你想驱动更大电流的例如57步进，或对delta 3D机型的精度有刚需，那么十分推荐diy或购买成品的Duet2 wifi（使用5路TMC2660步进驱动器 4.0A/30V 256细分，深水价13）。

## 为什么要将冰沙主板缩小为10x10？

由于10x10的四层板打样的价格越来越低，而大于10x10的四层板价格仍居高不下，相信不少尝试制作原版冰沙板的大侠一开始就被昂贵的打样费用劝退，因此设计出10x10的冰沙板很有意义，但冰沙主板作为开源了4年以上的开源硬件，其他大佬也设计过不少衍生版本，这些就包括：C3D Remix Board、SKR V-1.3、Cohesion3D Mini、Tiny Smoothie等，尽管替代形状的数量越来越多，但是**原始设计**（[Smoohieboard v1.1）能为中小型CNC机器（包括但不限于3D打印机，激光切割机和CNC铣床）供电和控制所需的所有电子零件：步进电机驱动器（5通道），加热器/冷却器驱动器（6通道Mosfet PWM），温度传感器（4通道），限位开关，SPI，I2C和用于硬件扩展的其他I / O，其中包括USB，UART，以太网和SD卡。替代设计也应包括这些元素或它们的类似物，或说明如何轻松添加它们。（实际上衍生的设计或多或少在板载资源方面都打了折扣）

目前衍生的设计与冰沙板的**相似性**并不太好，对初次接触衍生的主板、阅读原版的文档来学习如何使用冰沙板的朋友们不太友好，因为你需要知道衍生版相比原版的区别（引脚图变动、电子元件变动、布局变动等），因此本id(oldgerman)不另起炉灶，索性直接修改原版的Eagle工程，保留了官方原版（Smoohieboard v1.1）所有的元件和引出的连接器，并适度优化，设计出了Smoothieboard v1.3（10x10），做到原版极其相似的同时，缩小的代价是大功率MOS的载流需要从原来的12.5A降低至11A(20温升)。

## Gerber文件

- 外形尺寸：10x10cm
- 层压顺序：GTL G1 G2 GBL
- 最小孔径：0.3mm
- 最小线宽：6mil
- USB-C：槽孔背面Gerber文件是阻焊，厂家审核可能问开不开窗，两种都行看个人

## Pictures

### 2020-10-13 版本之前的三周目

<table>
    <td><image src = 2020-10-13_版本/image/三周目成品(1).jpg></td>
    <td><image src = 2020-10-13_版本/image/三周目成品(2).jpg></td>
    <td><image src = 2020-10-13_版本/image/三周目测试.png></td>
</table>

### 2020-10-21版本

[红豆](https://oshwhub.com/red_bean)和烂尾侠制作的2020-10-21成品，基本功能测试OK

### 2020-12-10版本

其实我把二周目板上的元件搬了个家。。。

<table>
    <td><image src = 2020-12-10_版本/image/2020-12-10版冰沙_成品tp_small.JPG></td>
    <td><image src = 2020-12-10_版本/image/2020-12-10版冰沙_成品bk_small.JPG></td>
</table>

## 开源硬件(OSHW)

冰沙主板10x10 是开源硬件

<table>
	<td></td></table>

## Acknowledgments

+ The Smoothieboard creators and the [Smoothieware](http://smoothieware.org/) team
+ [JP小可爱小路路](https://space.bilibili.com/479375532?from=search&seid=14974028502933777239)

## 附

基于冰沙主板v1.1的openpnp系统框图

## EAGLE design 2020-12-10_版本/Eagle/smoothieboard-10x10-1210.brd

Parts:
C1, C6, C8, C9, C10, C11, C12, C13, C14, C78, C79, C80, C81, C82, C83, C85: .1uF; 0603
C2, C3: 12pF; 0603
C4, C5: 18pF; 0603
C7: 10uF; EIA3216
C67: 1uF; C0603
FID1, FID2: FIDUCIAL; FIDUCIAL_1MM
IC1: LPC1769; LQFP100
J6: MTA04-100; 10X04MTA_ROUND
J12: USB_C_LONG-SYMBOL2-LAYER; USB-C-16P
JP1, JP7, JP9, JP10, JP12, JP15, JP29: CONN_04PTH; 1X04
JP2, JP3, JP4, JP6: 455-1750-1-ND; 1X03
JP14, JP16, JP19, JP21, JP22, JP26: M03POLAR; MOLEX-1X3
JP20: M03PTH; 1X03
JP23, JP24: M02PTH; 1X02
JP25: M03PTH; 1X03@1
JP32, JP33: M05PTH; 1X05
L1: INDUCTOR0603; 0603
LED1, LED2, LED3, LED4: LED0805; CHIPLED_0805
Q1: MOSFET-P; SOT23-R
Q2: 12MHz; CRYSTAL_3.2X2.5
R1, R2, R3, R14, R15, R16, R105, R106: 10K; 0603
R5, R6: 2.2K; 0603
R7: 1.5K; 0603
R8, R9: 33R; 0603
R10, R11, R12, R13, R93, R94, R96, R98, R100, R102: 1K; 0603
R17: 330R; 0603
R92, R95, R97, R99, R101, R103: 5.6K; 0603
R104: 0R; 0603
R107: 100K; 0603
S1, S2: TAC_SWITCHSMD; TACTILE_SWITCH_SMD
S3: SWITCH-MOMENTARY-LEDPTH; TACTILE-PTH-LED-12MM
SJ1, SJ2, SJ3: SOLDERJUMPER_2WAYS; SJ_3
U1: USD-SOCKETNEW; MICRO-SD-SOCKET-PP
U$9: OSHW-LOGOH; OSHW-LOGO-HUGE
U$13, U$14, U$16, U$18: SUN_HOLE_M3
VD1: USBLC6-2; SOT23-6

Connections:
3.3V: C1.2, C7.A (+), C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C67.2, IC1.19 (VBAT), IC1.28 (VDD(3V3)1), IC1.42 (VDD(REG)(3V3)1), IC1.54 (VDD(3V3)2), IC1.71 (VDD(3V3)3), IC1.84 (VDD(REG)(3V3)2), IC1.96 (VDD(3V3)4), JP1.1, JP2.1, JP4.1, L1.2, Q1.2 (S), R1.2, R2.2, R3.2, R14.2, R15.2, R16.2, R17.1, R107.2, SJ1.1, SJ2.1, SJ3.1, U1.4 (VCC); also elsewhere on the board
5V: SJ1.3, SJ2.3, SJ3.3; also elsewhere on the board
AGND: C6.2, IC1.11 (VSSA), IC1.15 (VREFN); also elsewhere on the board
AVCC: C6.1, IC1.10 (VDDA), IC1.12 (VREFP), L1.1; also elsewhere on the board
DIR1: IC1.80 (P0[5]/I2SRX_WS/TD2/CAP2[1]), JP7.2; also elsewhere on the board
DIR2: IC1.49 (P0[11]/RXD2/SCL2/MAT3[1]), JP9.2; also elsewhere on the board
DIR3: IC1.58 (P0[20]/DTR1/SCL1), JP12.2; also elsewhere on the board
DIR4: IC1.56 (P0[22]/RTS1/TD1), JP15.2; also elsewhere on the board
DIR5: IC1.50 (P2[13]/EINT3/I2STX_SDA); also elsewhere on the board
EN1: IC1.81 (P0[4]/I2SRX_CLK/RD2/CAP2[0]), JP7.1; also elsewhere on the board
EN2: IC1.48 (P0[10]/TXD2/SDA2/MAT3[0]), JP9.1; also elsewhere on the board
EN3: IC1.59 (P0[19]/DSR1/SDA1), JP12.1; also elsewhere on the board
EN4: IC1.57 (P0[21]/RI1/RD1), JP15.1; also elsewhere on the board
EN5: IC1.85 (P4[29]/TX_MCLK/MAT2[1]/RXD3); also elsewhere on the board
ENET_CRS: IC1.92 (P1[8]/ENET_CRS); also elsewhere on the board
ENET_MDC: IC1.87 (P1[16]/ENET_MDC); also elsewhere on the board
ENET_MDIO: IC1.86 (P1[17]/ENET_MDIO); also elsewhere on the board
ENET_REF_CLK: IC1.88 (P1[15]/ENET_REF_CLK); also elsewhere on the board
ENET_RXD0: IC1.91 (P1[9]/ENET_RXD0); also elsewhere on the board
ENET_RXD1: IC1.90 (P1[10]/ENET_RXD1); also elsewhere on the board
ENET_RX_ER: IC1.89 (P1[14]/ENET_RX_ER); also elsewhere on the board
ENET_TXD0: IC1.95 (P1[0]/ENET_TXD0); also elsewhere on the board
ENET_TXD1: IC1.94 (P1[1]/ENET_TXD1); also elsewhere on the board
ENET_TX_EN: IC1.93 (P1[4]/ENET_TX_EN); also elsewhere on the board
GND: C1.1, C2.2, C3.2, C4.1, C5.1, C7.C (-), C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C67.1, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C85.1, IC1.31 (VSS1), IC1.41 (VSS2), IC1.55 (VSS3), IC1.72 (VSS4), IC1.83 (VSS6), IC1.97 (VSS5), J6.4, J12.GND, J12.GND2 (GND), JP1.2, JP3.3, JP6.3, JP7.4, JP9.4, JP10.1, JP10.2, JP10.3, JP10.4, JP12.4, JP14.2, JP15.4, JP16.2, JP19.2, JP21.2, JP22.2, JP23.2, JP25.2, JP26.2, JP32.5, JP33.5, LED1.C, LED2.C, LED3.C, LED4.C, Q2.GND1, Q2.GND2, R104.1, R105.1, R106.1, S1.3, S1.4, S2.3, S2.4, S3.2, U1.6 (GND), U1.CD2 (SHIELD), U1.GND1 (SHIELD), VD1.2; also elsewhere on the board
ISP_BOOT: IC1.53 (P2[10]/EINT0/NMI), JP25.3, R15.1, S2.1, S2.2
JTAG-RTCK: IC1.100 (RTCK)
JTAG-TCK: IC1.5 (TCK/SWDCLK)
JTAG-TDI: IC1.2 (TDI)
JTAG-TDO: IC1.1 (TDO/SWO)
JTAG-TMS: IC1.3 (TMS/SWDIO)
JTAG-TRST: IC1.4 (TRST)
LED1: IC1.32 (P1[18]/USB_UP_LED/PWM1[1]/CAP1[0]), JP29.1, R10.2
LED2: IC1.33 (P1[19]/MC0A/USB_PPWR/CAP1[1]), JP29.2, R11.2
LED3: IC1.34 (P1[20]/MCFB0/PWM1[2]/SCK0), JP29.3, R12.2
LED4: IC1.35 (P1[21]/MCABORT/PWM1[3]/SSEL0), JP29.4, R13.2
MISO1: IC1.61 (P0[17]/CTS1/MISO0/MISO), JP3.1
MOSI1: IC1.60 (P0[18]/DCD1/MOSI0/MOSI), JP3.2
unnamed: C2.1, IC1.22 (XTAL1), Q2.2
unnamed: C3.1, IC1.23 (XTAL2), Q2.1
unnamed: J6.3, SJ1.2
unnamed: Q1.3 (D), R7.2
unnamed: J12.A6 (D+), J12.B6 (D+), R8.1, VD1.3, VD1.4
unnamed: J12.A7 (D-), J12.B7 (D-), R9.1, VD1.1, VD1.6
unnamed: JP24.1, R17.2, S3.C
unnamed: LED4.A, R13.1
unnamed: LED3.A, R12.1
unnamed: LED2.A, R11.1
unnamed: LED1.A, R10.1
unnamed: JP14.3, R94.1, R95.1
unnamed: JP14.1, JP16.1, JP19.1, JP21.1, JP22.1, JP26.1, R93.2, R94.2, R96.2, R98.2, R100.2, R102.2, SJ2.2
unnamed: JP16.3, R96.1, R97.1
unnamed: JP19.3, R98.1, R99.1
unnamed: JP22.3, R102.1, R103.1
unnamed: JP21.3, R100.1, R101.1
unnamed: JP26.3, R92.1, R93.1
unnamed: R5.2, R6.2, SJ3.2
unnamed: J12.A5 (CC1), R105.2
unnamed: J12.B5 (CC2), R106.2
P1_22: IC1.36 (P1[22]/MC0B/USB_PWRD/MAT1[0]), JP32.1; also elsewhere on the board
P1_23: IC1.37 (P1[23]/MCFB1/PWM1[4]/MISO0), JP32.2; also elsewhere on the board
P1_30: IC1.21 (P1[30]/VBUS/AD0[4]), JP32.4
P1_31: IC1.20 (P1[31]/SCK1/AD0[5]), JP32.3
P2.6: IC1.67 (P2[6]/PCAP1[0]/RI1/TRACECLK), JP33.1; also elsewhere on the board
P2.7: IC1.66 (P2[7]/RD2/RTS1), JP33.4; also elsewhere on the board
P2.9: IC1.64 (P2[9]/USB_CONNECT/RXD2), Q1.1 (G), R107.1
PLAY: IC1.51 (P2[12]/EINT2/I2STX_WS), JP23.1, R16.1, S3.4 (1)
PLAY_LED: IC1.82 (P4[28]/RX_MCLK/MAT2[0]/TXD3), JP24.2, S3.A
POT_SCL: IC1.47 (P0[1]/TD1/RXD3/SCL1); also elsewhere on the board
POT_SDA: IC1.46 (P0[0]/RD1/TXD3/SDA1); also elsewhere on the board
PWM0: IC1.69 (P2[4]/PWM1[5]/DSR1/TRACEDATA[1]), JP33.2; also elsewhere on the board
PWM1: IC1.68 (P2[5]/PWM1[6]/DTR1/TRACEDATA[0]), JP33.3; also elsewhere on the board
RESET: IC1.17 (RESET), JP25.1, R14.1, S1.1, S1.2
RSTOUT: IC1.14 (RSTOUT); also elsewhere on the board
RX_0: IC1.99 (P0[3]/RXD0/AD0[6]), J6.2
SCK1: IC1.62 (P0[15]/TXD1/SCK0/SCK), JP2.3
SCL: IC1.24 (P0[28]/SCL0/USB_SCL), JP1.4, R5.1
SDA: IC1.25 (P0[27]/SDA0/USB_SDA), JP1.3, R6.1
SD_CD: IC1.52 (P2[11]/EINT1/I2STX_CLK), JP20.3
SD_CS: IC1.79 (P0[6]/I2SRX_SDA/SSEL1/MAT2[0]), JP4.2, R1.1, U1.2 (CS)
SD_IRQ: IC1.27 (P3[25]/MAT0[0]/PWM1[2]), JP20.1
SD_MISO: IC1.77 (P0[8]/I2STX_WS/MISO1/MAT2[2]), JP6.1, R2.1, U1.7 (DO)
SD_MOSI: IC1.76 (P0[9]/I2STX_SDA/MOSI1/MAT2[3]), JP6.2, R3.1, U1.3 (DI)
SD_SCK: IC1.78 (P0[7]/I2STX_CLK/SCK1/MAT2[1]), JP4.3, U1.5 (SCK)
SD_WP: IC1.26 (P3[26]/STCLK/MAT0[1]/PWM1[3]), JP20.2
SHLD: J12.SHLD1 (SHLD), J12.SHLD2 (SHLD), J12.SHLD3 (SHLD), J12.SHLD4 (SHLD), J12.SHLD5 (SHLD), J12.SHLD6 (SHLD), J12.SHLD7 (SHLD), J12.SHLD8 (SHLD), R104.2
SSEL1: IC1.63 (P0[16]/RXD1/SSEL0/SSEL), JP2.2
STP1: IC1.75 (P2[0]/PWM1[1]/TXD1), JP7.3; also elsewhere on the board
STP2: IC1.74 (P2[1]/PWM1[2]/RXD1), JP9.3; also elsewhere on the board
STP3: IC1.73 (P2[2]/PWM1[3]/CTS1/TRACEDATA[3]), JP12.3; also elsewhere on the board
STP4: IC1.70 (P2[3]/PWM1[4]/DCD1/TRACEDATA[2]), JP15.3; also elsewhere on the board
STP5: IC1.65 (P2[8]/TD2/TXD2); also elsewhere on the board
TH1: IC1.9 (P0[23]/AD0[0]/I2SRX_CLK/CAP3[0]); also elsewhere on the board
TH2: IC1.8 (P0[24]/AD0[1]/I2SRX_WS/CAP3[1]); also elsewhere on the board
TH3: IC1.7 (P0[25]/AD0[2]/I2SRX_SDA/TXD3); also elsewhere on the board
TH4: IC1.6 (P0[26]/AD0[3]/AOUT/RXD3); also elsewhere on the board
TX_0: IC1.98 (P0[2]/TXD0/AD0[7]), J6.1
USB_D+: C5.2, IC1.29 (P0[29]/USB_D+), R7.1, R8.2
USB_D-: C4.2, IC1.30 (P0[30]/USB_D-), R9.2
VUSB: C85.2, J12.VBUS1 (VBUS), J12.VBUS2 (VBUS), VD1.5; also elsewhere on the board
X_MAX: C79.1, IC1.39 (P1[25]/MC1A/MAT1[1]), R95.2
X_MIN: C78.1, IC1.38 (P1[24]/MCFB2/PWM1[5]/MOSI0), R92.2
Y_MAX: C81.1, IC1.43 (P1[27]/CLKOUT/USB_OVRCR/CAP0[1]), R99.2
Y_MIN: C80.1, IC1.40 (P1[26]/MC1B/PWM1[6]/CAP0[0]), R97.2
Z_MAX: C83.1, IC1.45 (P1[29]/MC2B/PCAP1[1]/MAT0[1]), R103.2
Z_MIN: C82.1, IC1.44 (P1[28]/MC2A/PCAP1[0]/MAT0[0]), R101.2

Notes on the sheet:
SD Card connector
UART0
(Also for ISP Loading)
http://smoothieware.org
Symbol reversed in Sparkfun
Smoothieboard 10x10
by: Arthur Wolf
produced by: Trinity Labs
Licensed under GPL: http://www.gnu.org/licenses/gpl.html
Thanks for the support and contributions of the Reprap Community
M3*4
modified by: OldGerman

Parts:
C15, C16, C32, C33: .22uF; 0603
C17, C18, C19, C20, C25, C27, C28, C30, C31, C34, C35, C36, C37, C38, C40, C41, C43: .1uF; 0603
C21, C22, C23, C24: 10uF; EIA3216
C26, C29, C39, C42: 100uF/50V; PANASONIC_E
IC2, IC3, IC5, IC6: A5984; ETSSOP24
IC4: MCP44X1; TSSOP20
J1, J2, J3, J4: MTA04-100; 10X04MTA
JP13, JP30, JP31, JP36: JUMPER-2SMD-NC; SJ_2S
JP35: M02PTH; 1X02
R22, R23, R38, R39: NP; 0603
R24, R25, R26, R27, R28, R29, R40, R41, R42, R43, R44, R45: 10K; 0603
R30, R112, R113, R114, R115: 33K; 0603
R31, R32, R33, R34, R46, R47, R48, R49: 0.05R; 1206
R35, R36: 2.2K; 0603
R37: 100K; 0603
R108, R109, R110, R111: 4.7K; 0603
SJ4, SJ5, SJ6, SJ7: SOLDERJUMPER_2WAYS; SJ_3
SL1: CONN_08"; 1X08
VR1, VR2, VR3, VR4: TRIMPOT10K_BOURNS; TRIMPOT_BOURNS3MM

Connections:
3.3V: C25.1, C28.1, C31.2, C38.1, C41.1, IC4.17 (VDD), JP30.2, JP31.1, JP36.2, R22.1, R23.2, R24.2, R25.2, R28.2, R29.2, R30.2, R35.2, R36.2, R37.2, R38.2, R39.2, R41.2, R42.2, R44.2, R45.2, R112.2, R113.2, R114.2, R115.2; also elsewhere on the board
AGND: C21.C (-), C22.C (-), C23.C (-), C24.C (-), JP35.2, SL1.1, SL1.3, SL1.5, SL1.7; also elsewhere on the board
AVCC: JP35.1, R108.1, R109.1, R110.1, R111.1; also elsewhere on the board
DIR1: IC2.P14 (DIR); also elsewhere on the board
DIR2: IC3.P14 (DIR); also elsewhere on the board
DIR3: IC5.P14 (DIR); also elsewhere on the board
DIR4: IC6.P14 (DIR); also elsewhere on the board
EN1: IC2.P23 (^EN); also elsewhere on the board
EN2: IC3.P23 (^EN); also elsewhere on the board
EN3: IC5.P23 (^EN); also elsewhere on the board
EN4: IC6.P23 (^EN); also elsewhere on the board
GND: C15.1, C16.1, C25.2, C26.-, C27.2, C28.2, C29.-, C30.2, C31.1, C32.1, C33.1, C38.2, C39.-, C40.2, C41.2, C42.-, C43.2, IC2.P13 (GND1), IC2.P24 (GND2), IC2.P$1 (PAD), IC3.P13 (GND1), IC3.P24 (GND2), IC3.P$1 (PAD), IC4.3 (P3B), IC4.4 (HVC/A0), IC4.7 (VSS), IC4.8 (P1B), IC4.13 (P0B), IC4.16 (A1), IC4.18 (P2B), IC5.P13 (GND1), IC5.P24 (GND2), IC5.P$1 (PAD), IC6.P13 (GND1), IC6.P24 (GND2), IC6.P$1 (PAD), R26.2, R27.2, R31.1, R32.1, R33.1, R34.1, R40.2, R43.2, R46.1, R47.1, R48.1, R49.1, VR1.A, VR2.A, VR3.A, VR4.A; also elsewhere on the board
MS1: IC2.P05 (MS1), IC3.P05 (MS1), IC5.P05 (MS1), IC6.P05 (MS1), JP31.2; also elsewhere on the board
MS2: IC2.P06 (MS2), IC3.P06 (MS2), IC5.P06 (MS2), IC6.P06 (MS2), JP30.1; also elsewhere on the board
MS3: IC2.P10 (VDD), IC3.P10 (VDD), IC5.P10 (VDD), IC6.P10 (VDD), JP36.1; also elsewhere on the board
unnamed: C20.2, IC3.P01 (CP1)
unnamed: C20.1, IC3.P02 (CP2)
unnamed: IC2.P07 (^RESET), R25.1
unnamed: C18.2, IC3.P03 (VCP)
unnamed: IC3.P17 (SENSE1), R33.2
unnamed: IC3.P20 (SENSE2), R34.2
unnamed: IC3.P18 (OUT1A), J2.2
unnamed: IC3.P15 (OUT1B), J2.1
unnamed: IC3.P19 (OUT2A), J2.3
unnamed: IC4.15 (!RESET), R37.1
unnamed: IC3.P22 (OUT2B), J2.4
unnamed: IC4.1 (P3A), IC4.10 (P1A), IC4.11 (P0A), IC4.20 (P2A), R30.1
unnamed: IC3.P08 (ROSC), R23.1, R27.1
unnamed: C16.2, IC3.P04 (VREG)
unnamed: IC3.P09 (^SLEEP), R28.1
unnamed: C36.2, IC5.P01 (CP1)
unnamed: C36.1, IC5.P02 (CP2)
unnamed: C34.2, IC5.P03 (VCP)
unnamed: IC5.P17 (SENSE1), R46.2
unnamed: IC5.P20 (SENSE2), R47.2
unnamed: IC5.P18 (OUT1A), J3.2
unnamed: IC5.P15 (OUT1B), J3.1
unnamed: IC5.P19 (OUT2A), J3.3
unnamed: IC5.P22 (OUT2B), J3.4
unnamed: IC3.P07 (^RESET), R29.1
unnamed: IC5.P07 (^RESET), R42.1
unnamed: IC5.P08 (ROSC), R38.1, R40.1
unnamed: C32.2, IC5.P04 (VREG)
unnamed: IC6.P07 (^RESET), R45.1
unnamed: IC5.P09 (^SLEEP), R41.1
unnamed: C37.2, IC6.P01 (CP1)
unnamed: C37.1, IC6.P02 (CP2)
unnamed: C35.2, IC6.P03 (VCP)
unnamed: IC6.P17 (SENSE1), R48.2
unnamed: IC6.P20 (SENSE2), R49.2
unnamed: IC6.P15 (OUT1B), J4.1
unnamed: IC6.P19 (OUT2A), J4.3
unnamed: IC6.P22 (OUT2B), J4.4
unnamed: IC6.P08 (ROSC), R39.1, R43.1
unnamed: C33.2, IC6.P04 (VREG)
unnamed: IC6.P09 (^SLEEP), R44.1
unnamed: IC6.P18 (OUT1A), J4.2
unnamed: C19.2, IC2.P01 (CP1)
unnamed: C19.1, IC2.P02 (CP2)
unnamed: C17.2, IC2.P03 (VCP)
unnamed: IC2.P17 (SENSE1), R31.2
unnamed: IC2.P20 (SENSE2), R32.2
unnamed: IC2.P18 (OUT1A), J1.2
unnamed: IC2.P15 (OUT1B), J1.1
unnamed: IC2.P19 (OUT2A), J1.3
unnamed: IC2.P22 (OUT2B), J1.4
unnamed: IC2.P08 (ROSC), R22.2, R26.1
unnamed: C15.2, IC2.P04 (VREG)
unnamed: IC2.P09 (^SLEEP), R24.1
unnamed: R112.1, VR1.E
unnamed: R113.1, VR2.E
unnamed: R114.1, VR3.E
unnamed: R115.1, VR4.E
unnamed: IC2.P12 (REF), SJ4.2
unnamed: SJ4.1, VR1.S
unnamed: SJ5.1, VR2.S
unnamed: IC3.P12 (REF), SJ5.2
unnamed: SJ6.1, VR3.S
unnamed: IC5.P12 (REF), SJ6.2
unnamed: SJ7.1, VR4.S
unnamed: IC6.P12 (REF), SJ7.2
P0W: IC4.12 (P0W), SJ4.3
P1W: IC4.9 (P1W), SJ5.3
P2W: IC4.19 (P2W), SJ6.3
P3W: IC4.2 (P3W), SJ7.3
POT_SCL: IC4.5 (SCL), R36.1; also elsewhere on the board
POT_SDA: IC4.6 (SDA), R35.1; also elsewhere on the board
STP1: IC2.P11 (STEP); also elsewhere on the board
STP2: IC3.P11 (STEP); also elsewhere on the board
STP3: IC5.P11 (STEP); also elsewhere on the board
STP4: IC6.P11 (STEP); also elsewhere on the board
TH1: C21.A (+), R108.2, SL1.2; also elsewhere on the board
TH2: C22.A (+), R109.2, SL1.4; also elsewhere on the board
TH3: C23.A (+), R110.2, SL1.6; also elsewhere on the board
TH4: JP13.1, SL1.8; also elsewhere on the board
TH4_P: C24.A (+), JP13.2, R111.2
VBB: C17.1, C18.1, C26.+, C27.1, C29.+, C30.1, C34.1, C35.1, C39.+, C40.1, C42.+, C43.1, IC2.P16 (VBB1), IC2.P21 (VBB2), IC3.P16 (VBB1), IC3.P21 (VBB2), IC5.P16 (VBB1), IC5.P21 (VBB2), IC6.P16 (VBB1), IC6.P21 (VBB2); also elsewhere on the board

Notes on the sheet:
SW002:
MS1
MS2
FULL
HALF
4th
16 th
Thermistor Connection
http://smoothieware.org

Parts:
C44, C46, C47, C51, C52, C53, C62, C66: .1uF; 0603
C45, C50, C61: 10uF; EIA3216
C48: 1uF; C0603
C49: 470pF; C0603
C54, C55, C56, C57: 18pF; 0603
C58, C59: 12pF; 0603
C60, C63: 100uF/50V; PANASONIC_E
D4: SS110F; SMAF
D5: 15V; SMB
D7, D8: SS34F; SMAF
FB1: FERRITE; 0603
IC7: 74LVC1G04; SOT23-5
IC8: LAN8720; QFN24_4MM
IC11: 78L12F; SOT89
IC14: TC4427; SOIC8
JP11, JP27: JP1E; JP1
JP28: JP1E-SMSP; JP1-SMSP
LED5, LED6, LED7, LED8, LED10: LED0805; CHIPLED_0805
POWER: 5.08MM_CONN; 1715250000
Q3: 25MHz; CRYSTAL_3.2X2.5
Q6, Q7: IRF3205; TO220BV
Q8, Q9: BUK9832-55A; SOT230P700X160-4N
Q10: AOD4185; TO252
R50, R61: 330R; 0603
R51, R58, R59, R60, R69, R70, R73, R75: 22R; 0603
R52: 1.5K; 0603
R53, R62, R71, R72, R74, R76, R89, R90, R91: 10K; 0603
R54, R55, R56, R57: 49.9R; 0603
R63: 12.1K; 0603
R64: 1M; 0603
R65, R66, R67, R68, R78: 8.2K; 0603
RJ1: HR911105A
U$5, U$6, U$10: 5.08MM_CONN-NO-SIDE; 5.08-MOTHER_NO-SIDE
X1, X7, X8: 180G-2

Connections:
3.3V: C44.1, C50.A (+), C51.1, FB1.1, IC7.5 (VCC), IC8.9 (VDDIO), R52.2, R53.2; also elsewhere on the board
12VREG: C62.1, C66.1, IC11.1 (VO), IC14.6; also elsewhere on the board
ENET_CRS: R60.2; also elsewhere on the board
ENET_MDC: IC8.13 (MDC); also elsewhere on the board
ENET_MDIO: IC8.12 (MDIO), R52.1; also elsewhere on the board
ENET_REF_CLK: R51.2; also elsewhere on the board
ENET_RXD0: R58.2; also elsewhere on the board
ENET_RXD1: R59.2; also elsewhere on the board
ENET_RX_ER: IC8.10 (RXER), R53.1; also elsewhere on the board
ENET_TXD0: IC8.17 (TXD0); also elsewhere on the board
ENET_TXD1: IC8.18 (TXD1); also elsewhere on the board
ENET_TX_EN: IC8.16 (TXEN); also elsewhere on the board
GND: C44.2, C45.C (-), C46.2, C47.2, C48.2, C49.2, C50.C (-), C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.-, C61.C (-), C62.2, C63.-, C66.2, D4.A, IC7.3 (GND), IC8.THERM (GND), IC11.2 (GND), IC11.2@1 (GND), IC14.3, LED10.C, POWER.P$2, Q3.GND1, Q3.GND2, Q6.S, Q7.S, Q8.3 (S), Q9.3 (S), R50.1, R61.1, R62.1, R63.1, R71.1, R72.1, R74.2, R76.2, R89.2, R90.2, R91.2, RJ1.GND, RJ1.SHIELD0, RJ1.SHIELD1, U$5.P$1, X1.1; also elsewhere on the board
GPIO_FET: Q7.G, R70.2, R91.1
LED1/REGOFF: IC8.3 (LED1/REGOFF), RJ1.G+
LED2/NINTSEL: IC8.2 (LED2/NINTSEL), R62.2, RJ1.Y+
MOSFET_DRIVE: C60.+, IC11.3 (VI), JP11.1, JP27.1, R67.1, R68.1, U$5.P$2, U$6.P$2, U$10.P$2
unnamed: IC14.7, R69.1
unnamed: LED10.A, R78.1
unnamed: D8.A, LED6.C, Q9.2 (D), Q9.4 (D), X8.2
unnamed: IC14.5, R70.1
unnamed: R61.2, RJ1.G-
unnamed: C45.A (+), C46.1, C47.1, C52.1, C53.1, FB1.2, IC8.1 (VDD2A), IC8.19 (VDD1A), R54.1, R55.1, R56.1, R57.1, RJ1.P4, RJ1.P5
unnamed: IC8.8 (RXD0), R58.1
unnamed: R50.2, RJ1.Y-
unnamed: IC8.7 (RXD1), R59.1
unnamed: IC8.11 (CRS_DV), R60.1
unnamed: C59.1, IC8.4 (XTAL2), Q3.1, R64.2
unnamed: C58.1, IC8.5 (XTAL1), Q3.2, R64.1
unnamed: IC8.24 (RBIAS), R63.2
unnamed: Q8.1 (G), R73.1
unnamed: Q9.1 (G), R75.1
unnamed: IC7.2 (A), IC8.14 (NINT/REFCLKO)
unnamed: IC7.4 (Y), R51.1
unnamed: LED5.A, R65.2
unnamed: C48.1, C49.1, IC8.6 (VDDCR)
unnamed: D7.A, LED5.C, Q8.2 (D), Q8.4 (D), X7.2
unnamed: LED6.A, R66.2
unnamed: LED7.C, Q6.D, U$10.P$1
unnamed: LED8.C, Q7.D, U$6.P$1
unnamed: LED7.A, R67.2
unnamed: D5.A, Q10.1 (G), R89.1
unnamed: LED8.A, R68.2
P2.6: R75.2, R76.1; also elsewhere on the board
P2.7: IC14.4, R72.2; also elsewhere on the board
PWM0: R73.2, R74.1; also elsewhere on the board
PWM1: IC14.2, R71.2; also elsewhere on the board
PWM1_FET: Q6.G, R69.2, R90.1
RD+: C56.1, IC8.23 (RX+), R56.2, RJ1.RD+
RD-: C57.1, IC8.22 (RX-), R57.2, RJ1.RD-
RSTOUT: IC8.15 (NRST); also elsewhere on the board
SMALL_MOSFET_POWER: C61.A (+), D7.C, D8.C, JP28.1, R65.1, R66.1, X1.2, X7.1, X8.1
TD+: C54.1, IC8.21 (TX+), R54.2, RJ1.TD+
TD-: C55.1, IC8.20 (TX-), R55.2, RJ1.TD-
VBB: C63.+, D4.C, D5.C, JP11.2, JP27.2, JP28.2, Q10.2 (S), R78.2; also elsewhere on the board
VBB_IN: POWER.P$1, Q10.3 (D)

Notes on the sheet:
JP13,14 1-2: EXT FET- PS2
2-3: VBB
SMT FET PAIR
Small Power
TO220 FET PAIR
High Power
PWM Channel
GPIO Channel
SmoothieBoard ver 1.3
http://smoothieware.org
VS-25CTQ045S
单个杜邦跳线帽从VBB取电<=2A
每个跳线的额定电流仅为2A。这意味着，如果您要使用大于2A（对于小型MOSFET） 或4A（对于大型MOSFET，并且两个跳线都使用了2 x 2A），则不能使用这种方式为MOSFET供电。 例如，请勿使用跳线为加热床供电，因为它消耗的电流超过4A
IRF3205代替SOT240L RθJA Junction-to-Ambient 62℃/W TJ Operating Junction -55 to + 175℃ RDS(ON)=8mR, VGS=10V, I=15A, P=1.87W (Delta)TJ=115.94℃

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
SparkFun-Connectors-psa-change-usb-c: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
