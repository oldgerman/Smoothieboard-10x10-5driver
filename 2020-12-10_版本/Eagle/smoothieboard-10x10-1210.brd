# Repository oldgerman/Smoothieboard-10x10-5driver (continued)

## EAGLE design 2020-12-10_版本/Eagle/smoothieboard-10x10-1210.brd (continued)

Parts:
C64: 10uF; EIA3216
C65, C68, C69, C70, C71, C73, C75, C93: .1uF; 0603
C72: .22uF; 0603
C74: 100uF/50V; PANASONIC_E
C84: 100uF/25V; PANASONIC_D
C90: 10uF/50V; 1206
C91: 22uF/16V; 1206
C92: 150pF; 0603
D1, D2, D3, D9: SS34F; SMAF
IC9: MCP44X1; TSSOP20
IC10: LM1117-3.3V; SOT223
IC12: A5984; ETSSOP24
IC15: TC4427; SOIC8
J5: MTA04-100; 10X04MTA
JP5: M03PTH; 1X03
JP8, JP18, JP34: CONN_04PTH; 1X04
L3: 15uH; L0630
LED9, LED11, LED12: LED0805; CHIPLED_0805
PTC1: 0.75A; PTC1812
Q4: BUK9832-55A; SOT230P700X160-4N
Q5: IRF3205; TO220BV
R4, R125, R127: 100K; 0603
R18, R116: 33K; 0603
R19, R20, R81, R83, R86, R87: 10K; 0603
R21, R79: 0.05R; 1206
R77: 1K; 0603
R80: NP; 0603
R82, R88: 22R; 0603
R84, R85: 8.2K; 0603
R123: 210K; 0603
R124: 40.2K; 0603
R126: 200K; 0603
R128: 17.4K; 0603
SJ8: SOLDERJUMPER_2WAYS; SJ_3
U3: MP2565DN; ESOP8L-1.27-5X3.9MM
U$7: 5.08MM_CONN; 1715250000
U$11: FR000001; CERT-SMALL-SILK
U$12: FR000001; CERT-MED-SILK
VR5: TRIMPOT10K_BOURNS; TRIMPOT_BOURNS3MM
X9: 180G-2

Connections:
3.3V: C65.1, C68.2, C71.1, IC9.4 (HVC/A0), IC9.17 (VDD), IC10.2 (OUT), IC10.4 (OUT), JP5.1, JP8.1, R4.2, R18.2, R20.2, R77.2, R80.2, R81.2, R116.2; also elsewhere on the board
5V: C64.A (+), IC10.3 (IN), PTC1.P$1 (1); also elsewhere on the board
5V_IN_FUSE: C84.+, C91.1, D1.C, JP5.2, L3.2, PTC1.P$2 (2), R123.2
12VREG: C75.1, IC15.6; also elsewhere on the board
DIR5: IC12.P14 (DIR), JP18.2; also elsewhere on the board
EN: R127.1, R128.1, U3.2 (EN)
EN5: IC12.P23 (^EN), JP18.1; also elsewhere on the board
ETA_CURRENT: IC9.2 (P3W), JP34.3
GND: C64.C (-), C65.2, C68.1, C71.2, C72.1, C73.2, C74.-, C75.2, C84.-, C90.2, C91.2, D2.A, IC9.3 (P3B), IC9.7 (VSS), IC9.8 (P1B), IC9.13 (P0B), IC9.16 (A1), IC9.18 (P2B), IC10.1 (ADJ), IC12.P13 (GND1), IC12.P24 (GND2), IC12.P$1 (PAD), IC15.3, JP5.3, JP8.2, JP18.4, JP34.1, LED9.C, Q4.3 (S), Q5.S, R19.2, R21.1, R79.1, R83.2, R86.2, R87.1, R124.1, R125.1, R126.1, R128.2, U3.5 (GND), U3.PAD (GND), VR5.A; also elsewhere on the board
GPIO_FET1: Q5.G, R86.1, R88.1
MS1: IC12.P05 (MS1); also elsewhere on the board
MS2: IC12.P06 (MS2); also elsewhere on the board
MS3: IC12.P10 (VDD); also elsewhere on the board
unnamed: IC9.15 (!RESET), R4.1
unnamed: D9.A, LED11.C, Q4.2 (D), Q4.4 (D), X9.2
unnamed: IC9.1 (P3A), IC9.10 (P1A), IC9.11 (P0A), IC9.20 (P2A), R18.1
unnamed: C69.2, IC12.P01 (CP1)
unnamed: C69.1, IC12.P02 (CP2)
unnamed: C70.2, IC12.P03 (VCP)
unnamed: IC12.P17 (SENSE1), R21.2
unnamed: IC12.P20 (SENSE2), R79.2
unnamed: IC12.P18 (OUT1A), J5.2
unnamed: IC12.P15 (OUT1B), J5.1
unnamed: IC12.P19 (OUT2A), J5.3
unnamed: IC12.P22 (OUT2B), J5.4
unnamed: IC12.P08 (ROSC), R19.1, R80.1
unnamed: LED9.A, R77.1
unnamed: C72.2, IC12.P04 (VREG)
unnamed: IC12.P09 (^SLEEP), R20.1
unnamed: IC12.P07 (^RESET), R81.1
unnamed: Q4.1 (G), R82.1
unnamed: LED11.A, R84.2
unnamed: LED12.C, Q5.D, U$7.P$1
unnamed: LED12.A, R85.2
unnamed: IC15.7, R88.2
unnamed: R116.1, VR5.E
unnamed: SJ8.1, VR5.S
unnamed: IC12.P12 (REF), SJ8.2
unnamed: C93.1, D2.C, L3.1, U3.1 (SW)
unnamed: R123.1, R124.2, U3.4 (FB)
unnamed: C92.2, R125.2
unnamed: R126.2, U3.6 (FREQ)
unnamed: C93.2, U3.8 (BST)
unnamed: C92.1, U3.3 (COMP)
P1_22: R82.2, R83.1; also elsewhere on the board
P1_23: IC15.2, R87.2; also elsewhere on the board
POT_SCL: IC9.5 (SCL), JP8.4; also elsewhere on the board
POT_SDA: IC9.6 (SDA), JP8.3; also elsewhere on the board
PW5: IC9.12 (P0W), SJ8.3
STP5: IC12.P11 (STEP), JP18.3; also elsewhere on the board
THETA_CURRENT: IC9.19 (P2W), JP34.4
VBB: C70.1, C73.1, C74.+, D3.A, D9.C, IC12.P16 (VBB1), IC12.P21 (VBB2), R84.1, R85.1, U$7.P$2, X9.1; also elsewhere on the board
VBB_REG: C90.1, D3.C, R127.2, U3.7 (VIN)
VUSB: D1.A; also elsewhere on the board
ZETA_CURRENT: IC9.9 (P1W), JP34.2

Notes on the sheet:
MP1584芯片内部自带短路保护，短路电流阈值4.87A，去除过载后瞬时恢复。 MP1584电源模块实测输入26.3V，输出5V3A，带载五分钟，温升35°C左右 MP2565短路电流持续3.9A，没有烧片子
MP2565参数 典型输出5V/2.5A, 建议输入电压12-24V，开关频率500KHz 适用MP1584 此电路板基本按照datasheet的示例布板，修改R128为24.9k可以Pin to Pin使用MP1584，对于MP2565，R128为17.4k，详见datasheet P15和P16 MP2565 与 MP1584 MP2565相当于MP1584的高压版本，相比MP1584，MosFet耐压从28V提高到50V，对24V电压降压稳压更保险 此DCDC芯片的demo板见https://github.com/oldgerman/MP2565_EVM_V1

Board: 4 copper layers, 100.0 x 100.0 mm, 339 parts (6 on the bottom side), 252 nets.

Other parts of the board:
U$21: OSHW-LOGO-L

File 物料清单_BOM_Smoothieboard_10x10-v1.3.xlsx:

数量 | 参数 | 名称 | 封装 | 编号 | PM | 价格
 | 【半导体集成类】
1 | LPC1769FBD100 |  | LQFP100 | IC1 | 中国万货行18 | 14包邮
5 | A5984 |  | ETSSOP24 | IC2, IC3, IC5, IC6, IC12 | 深圳市盛创鸿卓电子科技有限公司 | 4包邮
2 | MCP4451-503/103 | MCP44X1 | TSSOP20 | IC4, IC9 | LC | 1+:15 10+ 11
1 | LAN8720 | LAN8720 | QFN24_4MM | IC8 | YX | 1.8~2
2 | TC4427COA | TC4427COA | SOIC8 | IC14, IC15 | 京东电子商城 | 2.4包邮
1 | 74LVC1G04 | 74LVC1G04 | SOT23-5 | IC7 | YX | 5pcs/1.4
1 | MP2565DN | MP2565DN | ESOP8L-1.27-5X3.9MM | U3 | YX | 2.45
1 | LM1117-3.3V | V_REG_LM1117SOT223 | SOT223 | IC10 | 京东电子商城/TX | 0.5
1 | 78L12F | 78L12F | SOT89 | IC11 | YX | 5pcs/1.4
 | 【半导体分立类】
1 | MOSFET_P -55V/-31A or MOSFET_P -30V/-70A or MOSFET_P -40V/-40A | IRFR5305TRPBF or AOD403 or AOD4185 | TO252 | Q10 | 优信 | 1.3 or 1.61 or .45
3 | MOSFET_N 55V/12A MOSFET_N 55V/3.1A VGSS(max)=2.0V | BUK9832-55A or IRLL024NTRPBF | SOT-223 | Q4, Q8, Q9 | LC YX | 3.5/1.55
3 | MOSFET_N | IRF3205 | TO220BV | Q5, Q6, Q7 | YX | 1.81
1 | MOSFET_P | SI2301DS(威世) | SOT23-R | Q1 | YX | 0.28
6 | 3A/40V | SS34F(MOD) | SMAF | D1, D2, D3,, D7, D8, D9 | YX | 10pcs/1.3
1 | 1A/100V | SS110F/SS110 | SMAF/SMA | D4 | YX | 10pcs/0.7
1 | 15v/3W | SMB5929BT3G | SMB | D5 | 深圳市坤烽芯城科技 | 10pcs/3.2
12 | LED 红色*1，绿色*4，黄色*7 | LED | CHIPLED_0805 | LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12 | YX | 20pcs/1.0
1 | ESD | USBLC6-2SOT23-6 | SOT23-6 | VD1 | YX | 0.5
1 | 0.75A工作/1.5A跳闸 | PTC1812 | PTC1812 | PTC1 | YX | 0.2
 | 【电容类】
4 | 12pF/50V/COG | C-EU | 0603 | C2, C3, C58, C59 | YX | 100pcs/2.0
6 | 18pF/50V/COG | C-EUC0603 | 0603 | C4, C5, C54, C55, C56, C57 | YX | .100pcs/2.0
1 | 150pF/50V/COG | CAP_CERAMIC0603 | 0603 | C92 | YX | 50pcs/1.5
1 | 470pF/50V/X7R | C-EUC0603 | 0603 | C49 | YX | 100pcs/2.0
49 | .1uF/50V/X7R | C-EU | 0603 | C1, C44, C46, C47, C51, C52, C53, C62, C65, C66, C75, C6, C8, C9, C10, C11, C12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 | YX | 50pcs/1.5
5 | .22uF/50VX7R | C-EU | 0603 | C15, C16, C32, C33, C72 | YX | 50pcs/3.5
2 | 1uF/50V/X5R | C-EUC0603 | 0603 | C48, C67 | YX | 5PCS/3.0
10 | 10uF/50V/X5R | CAP_CERAMIC1206 | 1206 | C7, C21, C22, C23, C24, C45, C50, C61, C64, C90 | YX | 10pcs/3.5
1 | 22uF/16V/X5R | CAP_CERAMIC1206 | 1206 | C91 | YX | 20pcs/2.6
1 | 100uF/25V 6.3*7.7mm | CAP_POLD | PANASONIC_D | C84 | YX | 0.31
7 | 100uF/50V 8*10.5mm | CAP_POLE | PANASONIC_E | C26, C29, C39, C42, C60, C63, C74 | YX | 0.14
 | 【电阻类】
10 | 0.05R: 1/2W/1W (最好使用1% 50ppm) | RESISTOR1206 | 1206 | R21, R31, R32, R33, R34, R46, R47, R48, R49, R79 | LC YX | 10pcs/3.6
1 | 0R | R-US_ | 0603 | R104 | LC | 100pcs/1.0
12 | 22R | R-US_ | 0603 | R8, R9, R51, R58, R59, R60, R69, R70, R73, R75, R82, R88 | LC | 100pcs/1.0
4 | 49.9R | R-US_ | 0603 | R54, R55, R56, R57 | LC | 100pcs/1.0
3 | 330R | R-US_ | 0603 | R17, R50, R61 | LC | 100pcs/1.0
11 | 1k | R-US_ | 0603 | R10, R11, R12, R13, R77, R93, R94, R96, R98, R100, R102 | LC | 100pcs/1.0
2 | 1.5K(or 2.2k) | R-US_ | 0603 | R7, R52 | LC | 100pcs/1.0
4 | 2.2k | R-US_ | 0603 | R5, R6, R35, R36 | LC | 100pcs/1.0
4 | 4.7K | R-US_ | 0603 | R108, R109, R110, R111 | LC | 100pcs/1.0
6 | 5.6k | R-US_ | 0603 | R92, R95, R97, R99, R101, R103 | LC | 100pcs/1.0
7 | 8.2K(or 10k) | R-US_ | 0603 | R65, R66, R67, R68, R78, R84, R85 | LC | 100pcs/1.0
35 | 10K | R-US_ | 0603 | R1, R2, R3, R14, R15, R16, R19, R20, R24, R25, R26, R27, R28, R29, R40, R41, R4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 | LC | 100pcs/1.0
1 | 12.1K | R-US_ | 0603 | R63 | LC | 100pcs/1.0
1 | 17.4k | RESISTOR0603 | 0603 | R128 | LC | 100pcs/1.0
7 | 33.2K/6.65K (最好使用1% 50ppm) | R-US_ | 0603 | R18, R30, R112, R113, R114, R115, R116 | LC | 100pcs/1.0 or 50pcs/2.5(1% 50ppm)
1 | 40.2k | RESISTOR0603 | 0603 | R124 | LC | 100pcs/1.0
5 | 100K | R-US_ | 0603 | R4, R37, R107, R125, R127 | LC | 100pcs/1.0
1 | 200k | RESISTOR0603 | 0603 | R126 | LC | 100pcs/1.0
1 | 210k | RESISTOR0603 | 0603 | R123 | LC | 100pcs/1.0
1 | 1M | R-US_ | 0603 | R64 | LC | 100pcs/1.0
 | 【电感/磁珠类】
1 | 39nH 200mA DCR:3Ohm | INDUCTOR0603 | 0603 | L1 | YX | 100pcs/2.0
1 | 30Ohms@100MHz 5A DCR: 10mOhm | FERRITE | 0603 | FB1 | LC | 50pcs/3.0
1 | 15uH | INDUCTOR'0630' | L0630 | L3 | YX | 0.2
 | 【杂项类】
1 | 12MHz | CRYSTALTHIN | CRYSTAL_3.2X2.5 | Q2 |  | 0.4
1 | 25MHz | CRYSTALTHIN | CRYSTAL_3.2X2.5 | Q3 |  | 0.5
5 | 3x3mm 50K/10K贴片机械式电位器(二选一) | TRIMPOT10K_BOURNS | TRIMPOT_BOURNS3MM | VR1, VR2, VR3, VR4, VR5 |  | 0.26
1 | RJ-45带网络变压器 | HR911105A | HR911105A | RJ1 |  | 4.6
1 | 盘下式micro-SD卡槽 | USD-SOCKETNEW | MICRO-SD-SOCKET-PP | U1 |  | 0.8
1 | USB-C-16P四角焊接式母座 | USB_C2-LAYER | USB-C-16P | J12 |  | 0.5
2 | 四角贴片开关 4x4(柄长推荐3mm) | TAC_SWITCHSMD | TACTILE_SWITCH_SMD | S1, S2 |  | 0.07
1 | 12x12mm带灯开关 | SWITCH-MOMENTARY-LEDPTH | TACTILE-PTH-LED-12MM | S3 |  | 1.2
3 | 2.54mm跳线帽 | JP1E | JP1 | JP11, JP27, JP28 |  | 以上合计152/123（使用MCP/机械电位器）
2 | 5.08mm 2针 插座(全包式) | 5.08MM_CONN | 1715250000 | POWER, U$7
3 | 5.08mm 2针 插座(紧凑式) | 5.08MM_CONN-NO-SIDE | 5.08-MOTHER_NO-SIDE | U$5, U$6, U$10
5 | 5.08mm 2针 插头
4 | 3.5mm 2针 插座 (小功率MOSFET) | 180G-2 | 180G-2 | X1, X7, X8, X9
4 | 3.5mm 2针 插头
6 | KF2510-4P插座 (步进电机和串口) | MTA04-100 | 10X04MTA | J1, J2, J3, J4, J5, J6
6 | KF2510-4P胶壳
6 | KF2510-3P插座 (限位开关) | M03POLAR | MOLEX-1X3 | JP14, JP16, JP19, JP21, JP22, JP26
6 | KF2510-3P胶壳
50 | KF2510 端子(自备SN压线钳)
4 | 2.54mm杜邦插针20pin（左侧合计） | 3个 | 1X02 | JP23, JP24, JP35
 |  | 7个 | 1X03 | JP2, JP3, JP4, JP6, JP5, JP20, JP25
 |  | 10个 | 1X04 | JP1, JP7, JP8, JP9, JP10, JP12, JP15, JP18, JP29, JP34
 |  | 2个 | 1X05 | JP32, JP33
 | 【无元件】
5 | NP | R-US_ | 0603 | R22, R23, R38, R39, R80
1 | FR000001 | CERT-SMALL | CERT-SMALL-SILK | U$11
1 | FR000001 | CERT-MEDIUM | CERT-MED-SILK | U$12
2 | FIDUCIAL{Mark点} | FIDUCIAL | FIDUCIAL_1MM | FID1, FID2
1 | OSHW-LOGOH | OSHW-LOGOH | OSHW-LOGO-HUGE | U$9
4 |  | JUMPER-2SMD-NC | SJ_2S | JP13, JP30, JP31, JP36
1 |  | CONN_08";1X08" | SL1 | Multi connection point. Often used as Generic Header-pin footprint for 0.1 inch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
8 |  | SOLDERJUMPER_2WAYS | SJ_3 | SJ1, SJ2, SJ3, SJ4, SJ5, SJ6, SJ7, SJ8
4 |  | SUN_HOLE_M3 | SUN_HOLE_M3 | U$13, U$14, U$16, U$18

## Commit log

2020-10-19 首次提交
2020-10-19 第2次提交
2020-10-19 pdf小修改
2020-10-21 20201021-加宽A5984的铜箔宽度
2020-10-21 板子已寄出，等测试结果
2020-10-21 add schematics
2020-10-21 添加gerber文件工艺说明
2020-10-21 pinmap 修改为2020-10-21
2020-10-21 修改pinmap为1021
2020-10-21 pinmap改为1021
2020-10-21 补上引脚定义的蓝色虚线
2020-10-22 pdf 小修改
2020-10-22 修改README
2020-10-26 pdf html格式错误，修改一下
2020-10-27 pdf修改一下
2020-10-27 pdf修改
2020-10-29 删掉多余的辅助文件
2020-12-17 last
2020-12-29 2020-last
